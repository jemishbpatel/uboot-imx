## board/liveuboard/Kconfig
```kconfig
if TARGET_LIVEUBOARD

config SYS_BOARD
	default "liveuboard"

config SYS_CONFIG_NAME
	default "liveuboard"

endif
```
